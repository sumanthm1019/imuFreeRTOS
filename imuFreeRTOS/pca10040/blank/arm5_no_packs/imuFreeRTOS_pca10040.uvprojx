# Keil uVision project imuFreeRTOS_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF52832 NRF52 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 BSP_DEFINES_ONLY NRF_LOG_USES_RTT
  c include: ..\..\..\..\imuFreeRTOS;..\config;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\boards;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\common;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\delay;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\hal;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\uart;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\bsp;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log\src;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\timer;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\button;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\toolchain;..\..\..;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\segger_rtt;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\freertos;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\freertos\source\include;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\freertos\source\portable\MemMang;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\freertos\config;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\freertos\portable\ARM\nrf52;..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\freertos\portable\CMSIS\nrf52
  asm define: NRF52832 NRF52 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 BSP_DEFINES_ONLY
  asm misc: --cpreproc_opts=-DNRF52832,-DNRF52,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBSP_DEFINES_ONLY
  asm include: ..\..\..\config\twi_sensor_pca10040;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/boards/: boards.c
  group nRF_Drivers
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c nrf_nvic.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/mem_manager/: mem_manager.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/timer/: app_timer.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/button/: app_button.c
  group nRF_Log
    ../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../nRF5_SDK_12.3.0_d7731ad/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group FreeRTOS
    ../../../../nRF5_SDK_12.3.0_d7731ad/external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/external/freertos/portable/ARM/nrf52/: port.c
    ../../../../nRF5_SDK_12.3.0_d7731ad/external/freertos/portable/CMSIS/nrf52/: port_cmsis_systick.c port_cmsis.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
